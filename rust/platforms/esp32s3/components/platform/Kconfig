## rust/platforms/esp32s3/components/platform/Kconfig
```kconfig
menu "Cordial"
config CORDIAL_DEVELOPMENT
    bool "Enable development ROM bootloader entry"
    default n
endmenu
```
